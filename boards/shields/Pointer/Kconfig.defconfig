## boards/shields/Pointer/Kconfig.defconfig
```kconfig
if SHIELD_POINTER

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Pointer"

endif
```
